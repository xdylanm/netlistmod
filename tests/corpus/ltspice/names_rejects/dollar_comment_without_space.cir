M8 reject
R1 a 0 1k $c
.end
