M8 reject
R1 a(b 0 1k
.end
