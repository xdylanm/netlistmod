M8 LTspice ground aliases and case folding
V1 IN 0 3
R1 in ÄN 1k
R2 än ÄN 1k
R3 äN STRASSE 1k
R4 straße GND 1k
R5 out gnd 1k
R6 out Gnd 1k
R7 out 00 1k
R8 00 0 1k
.op
.end
