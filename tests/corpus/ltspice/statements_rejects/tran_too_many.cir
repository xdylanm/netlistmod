M8 reject
.tran 1u 1m 0 1u 5u
.end
