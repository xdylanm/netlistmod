M8 reject
.tran 1m foo
.end
