M8 reject
.model dm D(Is=x)
.end
