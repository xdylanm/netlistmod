M8 reject
.param x
.end
