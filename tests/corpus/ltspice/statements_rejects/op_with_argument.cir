M8 reject
.op 1
.end
