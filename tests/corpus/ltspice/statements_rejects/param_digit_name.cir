M8 reject
.param 1a=1
.end
