M8 reject
R1 a 0 1
.end
R2 a 0 1
