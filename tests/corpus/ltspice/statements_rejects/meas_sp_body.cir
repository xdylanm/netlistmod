M8 reject
.meas op
.end
