M8 reject
.ic I(R1)=1
.end
