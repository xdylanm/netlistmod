M8 reject
.nodeset I(L1)=1
.end
