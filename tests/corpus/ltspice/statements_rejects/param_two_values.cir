M8 reject
.param x=1 2
.end
