M8 reject
.nodeset all=1
.end
