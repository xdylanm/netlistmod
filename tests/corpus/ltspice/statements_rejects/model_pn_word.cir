M8 reject
.model dm D(pn=1N4148A)
.end
