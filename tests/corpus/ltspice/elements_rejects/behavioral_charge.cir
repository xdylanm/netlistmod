M8 reject
C1 a 0 Q=1u*x
.end
