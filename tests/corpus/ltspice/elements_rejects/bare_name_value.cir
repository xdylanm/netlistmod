M8 reject
R1 a b R47
.end
