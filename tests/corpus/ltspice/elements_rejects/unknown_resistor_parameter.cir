M8 reject
R1 a b 1k foo=1
.end
