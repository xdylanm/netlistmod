M8 reject
V1 a 0 1 Rser=1 AC 1
.end
