M8 reject
I1 a 0 1m Rser=1
.end
