M8 reject
L1 a b 1m tc=1m
.end
