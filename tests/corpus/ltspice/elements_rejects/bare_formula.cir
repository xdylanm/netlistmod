M8 reject
R1 a b x*3
.end
