M8 reject
I1 a 0
.end
