M8 reject
Q1 c b e npn
.end
