M8 reject
R1 a b 1k \\
m=2
.end
