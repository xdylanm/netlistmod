M8 reject
C1 a b 1u Rsr=1
.end
