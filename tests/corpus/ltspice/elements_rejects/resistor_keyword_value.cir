M8 reject
R1 a b R=1k
.end
