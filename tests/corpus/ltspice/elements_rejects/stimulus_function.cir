M8 reject
V1 a 0 SINE(0 1 1k)
.end
