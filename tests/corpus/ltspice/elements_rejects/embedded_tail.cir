M8 reject
R1 a b 1k5x
.end
