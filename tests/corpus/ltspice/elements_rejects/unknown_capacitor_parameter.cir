M8 reject
C1 a b 1u foo=1
.end
