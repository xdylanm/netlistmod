M8 reject
L1 a 0 Flux=1m*x
.end
