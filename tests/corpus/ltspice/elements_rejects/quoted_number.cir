M8 reject
C1 a b 1u V="6.3"
.end
