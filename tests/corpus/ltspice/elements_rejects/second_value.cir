M8 reject
R2 out 0 1k 5k
.end
