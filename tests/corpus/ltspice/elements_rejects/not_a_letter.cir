M8 reject
N1 a b c
.end
