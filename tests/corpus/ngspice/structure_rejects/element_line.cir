title
Q1 c b e npn
.end
