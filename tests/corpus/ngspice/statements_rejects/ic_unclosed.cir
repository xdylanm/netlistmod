M4 reject
V1 in 0 DC 1
.ic v(1=5
.end
