M4 reject
V1 in 0 DC 1
.model
.end
