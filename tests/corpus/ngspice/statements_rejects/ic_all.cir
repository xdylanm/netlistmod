M4 reject
V1 in 0 DC 1
.ic all=1
.end
