title
.model dm d is=1e-14 1e-15
.end
