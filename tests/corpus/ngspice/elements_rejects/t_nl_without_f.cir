title
T1 a 0 b 0 z0=50 nl=0.25
.end
