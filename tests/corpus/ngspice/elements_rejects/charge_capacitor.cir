title
C1 a b q='1u*V(a,b)'
.end
