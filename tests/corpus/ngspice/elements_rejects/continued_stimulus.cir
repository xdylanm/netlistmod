title
V1 a 0
+ SIN(0 1
+ 1MEG)
.end
