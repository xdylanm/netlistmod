title
P1 a1 a2 0 b1 b2 pmod
.end
